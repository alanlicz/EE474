<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\task1.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\task2a.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\task2b.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\task2c.ewp</path>
    </project>
    <batchBuild />
</workspace>
