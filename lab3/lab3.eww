<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\task1a\task1a.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\task1b\task1b.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\task2a\task2a.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\task2b\task2b.ewp</path>
    </project>
    <batchBuild />
</workspace>
